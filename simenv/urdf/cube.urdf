Commit message: Tolerance Issues Fixed. Perception Abandoned

File: simenv/urdf/cube.urdf (robot description, URDF)
Before this commit: robot None, 1 links, 0 joints
Links:
- removed link cube
- added link camera, mass 1.0; collision box size=0.1 0.1 0.1; visual box size=0.1 0.1 0.1
